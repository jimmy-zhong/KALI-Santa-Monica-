# IAR project kali_sm_a6_20200630.ewp, settings and files
configuration STM3210C_EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107VC ST STM32F107VC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F107xC; USE_STM3210C_EVAL; USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include; ..\..\..\..\..\..\Drivers\BSP\Components; Middlewares\Third_Party\FatFs\src; ..\..\..\..\IAR LIBRARY\STM32Cube_FW_F1_V1.8.0\Utilities\Log; INC; ..\Drivers\STM32F1xx_HAL_Driver\Inc; ..\Drivers\BSP\STM3210C_EVAL; Middlewares\ST\STM32_USB_Host_Library\Core\Inc; Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc; Ethernet; UTILITY; ..\adau1452
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: kali_sm_a6_20200630.bin
  ILINK.IlinkOutputFile: kali_sm_a6_20200630.out
  ILINK.IlinkIcfFile: stm32f107xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f107xc.s
  group Application/User
    SRC/: app.c biquads.c file_operations.c main.c misc.c PresetEQ.c stm32f1xx_it.c usbh_conf.c usbh_diskio.c
  group Doc
    ./: RCC_CFGR2.txt
    ../: readme.txt
  group Drivers/CMSIS
    ./: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_eth.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_mmc.c stm32f1xx_hal_msp_template.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_adc.c stm32f1xx_ll_crc.c stm32f1xx_ll_dma.c stm32f1xx_ll_tim.c stm32f1xx_ll_usb.c
  group Ethernet
    Ethernet/: device.c dhcp.c socket.c sockutil.c tcp_proc.c ult.c w5500.c
  group INCLUDE
    ../adau1452/: Santa_Monica_IC_1.h Santa_Monica_IC_1_PARAM.h Santa_Monica_IC_1_REG.h
    INC/: SigmaStudioFW.h stm32f107xc.h
    UTILITY/: SPIx.h
    STM32F1xx_HAL_Driver/Inc/: stm32f1xx_hal.h
  group Middlewares/FatFs
    Middlewares/Third_Party/FatFs/src/: ff.c
    Middlewares/Third_Party/FatFs/src/option/: unicode.c
  group Middlewares/STM32_USBH_Library/Class/MSC
    Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Middlewares/STM32_USBH_Library/Core
    Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group UTILITY
    UTILITY/: spix.c
