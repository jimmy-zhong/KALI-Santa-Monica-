<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\kali_sm_a6_20200630.ewp</path>
  </project>
  <batchBuild/>
</workspace>


